# IAR project Device.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x0000
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: inc; src
  ICCSTM8.IccLang: 1
  OBJCOPY.OOCOutputFile: Device.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenHeapSize: 0x0
  ICCSTM8.CCDefines: NDEBUG; STM8S003; F_CPU=2000000UL
  ICCSTM8.CCIncludePath2: stm8\common; stm8\hal; stm8\drivers; stm8\wake; modbus\rtu\; modbus\include\; modbus\stm8port\
  ICCSTM8.IccLang: 2
  ILINK.IlinkOutputFile: Light.out
  group (top)
    ./: main.cpp
  group common
    ../stm8_framework/common/: circularBuffer.h string_utils.h type_traits.h
    stm8/common/: string_utils.cpp
  group drivers
    ../stm8_framework/drivers/: adc_keyboard.h am2302.h encoder.h s1d157xx.h ssd1306.h
    ../../Libs/mcu_common/: hd44780.h
  group hal
    ../stm8_framework/hal/: adc.h clock.h crc.h delay.h flash.h gpio.h i2c.h itc.h onewire.h pinlist.h spi.h stm8s.h timers.h uart.h
    stm8/hal/: crc.cpp
  group modbus
    modbus/: mb.c
  group modbus/Functions
    modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group modbus/Include
    modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group modbus/Rtu
    modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group modbus/stm8port
    modbus/stm8port/: port.h portevent.cpp portserial.cpp porttimer.cpp
  group wake
    ../stm8_framework/wake/: led_driver_mbi6651.h led_driver_ncp3066.h ledStrip.h power_supply.h relays.h sensors.h switch.h wake_base.h
